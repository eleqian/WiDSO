# Keil uVision project App.uvproj, settings and files
target App_Stand (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: App_Stand
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\src;..\usb;..\drv;..\sys;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: main.c blaster.c blaster_port.c ft245rom.c ringbuf.c
  group drv
    ../drv/: platform_config.h base.h bitband.h led.c timebase.c skey.c
  group usb
    ../usb/: usb_conf.h hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group sys
    ../sys/: stm32_it.c system_stm32f10x.c system_stm32f10x_iap.c startup_stm32f10x_md.s
  group usb_drv
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group periph_drv
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_pwr.c
  group doc
    ../: readme.txt
target App_IAP (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App_IAP
  AfterMake: F:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\update.bin .\out\App_IAP.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\src;..\fatfs;..\drv;..\chip8;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
