# Keil uVision project USBBootLoader.uvprojx, settings and files
target USBBootLoader (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_BL
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\src;..\drv;..\udisk;..\sys;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: main.c
  group drv
    ../drv/: led.c timebase.c base.h config.h
  group udisk
    ../udisk/: hw_config.c mass_mal.c memory.c scsi_data.c usb_scsi.c usb_bot.c usb_prop.c usb_endp.c usb_desc.c usb_istr.c usb_pwr.c usb_conf.h
  group sys
    ../sys/: stm32_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
